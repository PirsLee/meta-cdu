FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-interface-add-new-xyz-openbmc_project-Configuration-.patch \
            file://0001-interface-revise-DevicePath-to-DeviceAddress.patch \
            "

